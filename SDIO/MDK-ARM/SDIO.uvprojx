# Keil uVision project SDIO.uvprojx, settings and files
target SDIO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SDIO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;     ../Drivers/STM32F1xx_HAL_Driver/Inc;     ../Middlewares/Third_Party/FatFs/src;     ../Middlewares/Third_Party/FatFs/src/drivers;     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;     ../Drivers/CMSIS/Include;     ../MP3/real;     ../MP3/pub
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: lcd.c MP3_decoder.c file_sys_func.c main.c bsp_driver_sd.c fatfs.c stm32f1xx_it.c stm32f1xx_hal_msp.c wav_decoder.c
    ../Inc/: wav_decoder.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group MP3
    ../Mp3/: mp3dec.c mp3tabs.c
    ../Mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../MP3/real/arm/: asmmisc.s asmpoly.s
software components: CMSIS:CORE 4.3.0
